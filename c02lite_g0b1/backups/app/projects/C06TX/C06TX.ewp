# IAR project C06TX.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: AT32F413RC ArteryTek AT32F413RC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_HD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06TX; LIBRARY_VERSION; SYSTICK; C06_V1_2
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\Zox\drivers\include; ..\..\..\Zox\utils; ..\..\..\Zox\include; ..\..\..\Zox; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\C06; ..\..\..\APP\; ..\..\..\APP\include; ..\..\..\lib\CMSIS\CM4\DeviceSupport; ..\..\..\lib\AT32F4xx_StdPeriph_Driver\src; ..\..\..\lib\AT32F4xx_StdPeriph_Driver\inc; ..\..\..\lib\CMSIS\CM4\DeviceSupport\startup\iar; ..\..\..\lib\CMSIS\CM4\CoreSupport; ..\..\..\Zox\FreeRTOS\include; ..\..\..\Zox\drivers\DrvFs; ..\..\..\Zox\FreeRTOS\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: E:\git\C02Lite_Atery\C02Lite_Atery\Zox\FreeRTOS\include
  OBJCOPY.OOCOutputFile: C06TX.bin
  ILINK.IlinkOutputFile: C06TX.out
  ILINK.IlinkIcfFile: ..\..\..\BSP\C06\AT32F413xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release_413RB (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F413RB ArteryTek AT32F413RB
configuration release_413RC (ARM)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\BSP\C06\AT32F413xC.icf
  group APP/C06TXController
    ../../Controller/C06TXController/: C06TXController.cpp
  group APP/CanDetector
    ../../CanDetector/: CanDetector.cpp
  group APP/Car
    ../../Car/: Car.cpp
  group APP/Car/Maxus
    ../../Car/Maxus/: Maxus.cpp
  group APP/Main
    ../../Main/: appMain.cpp
  group APP/PV
    ../../PV/C06TX_PV/: C06TX_PV.cpp
    ../../PV/: PV.cpp
  group BSP/C06
    ../../../BSP/: at32f4xx_it.c system_at32f4xx.c
    ../../../BSP/C06/: board.cpp
  group Lib/AT32F4xx_StdPeriph_Driver
    ../../../lib/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_crc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c misc.c
  group Lib/CMSIS
    ../../../lib/CMSIS/CM4/DeviceSupport/startup/iar/: startup_at32f413rx_md.s
  group Zox
    ../../../Zox/: main.cpp zdebug.cpp Zox.cpp
  group Zox/drivers
    ../../../Zox/drivers/: Driver.cpp DrvCAN.cpp DrvGPIO.cpp DrvGPTimer.cpp DrvLED.cpp DrvPWR.cpp DrvSPI.cpp DrvTJA1041.cpp DrvUSART.cpp DrvWatchDog.cpp DrvWindowWatchDog.cpp
  group Zox/DrvFS
    ../../../Zox/drivers/DrvFs/: diskio.c DrvFs.cpp SPI_SD_driver.c tff.c
  group Zox/FreeRTOS/core
    ../../../Zox/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Zox/FreeRTOS/port
    ../../../Zox/FreeRTOS/include/: FreeRTOSConfig.h
    ../../../Zox/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../Zox/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Zox/utils
    ../../../Zox/utils/: Delay.cpp RingBuffer.cpp SysTick.c
