# IAR project OBDTester.ewp, settings and files
configuration release_V1_5 (ARM, debug)
  General.OGChipSelectEditMenu: AT32F413RB ArteryTek AT32F413RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; LIBRARY_VERSION; SYSTICK
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\Zox\drivers\include; ..\..\..\Zox\utils; ..\..\..\Zox\include; ..\..\..\Zox; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\OBD; ..\..\..\APP\; ..\..\..\APP\include; ..\..\..\lib\CMSIS\CM4\DeviceSupport; ..\..\..\lib\AT32F4xx_StdPeriph_Driver\src; ..\..\..\lib\AT32F4xx_StdPeriph_Driver\inc; ..\..\..\lib\CMSIS\CM4\DeviceSupport\startup\iar; ..\..\..\lib\CMSIS\CM4\CoreSupport; ..\..\..\Zox\FreeRTOS\include; ..\..\..\Zox\FreeRTOS\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: G:\git\C02Lite_Atery\C02Lite_Atery\Zox\FreeRTOS\include
  OBJCOPY.OOCOutputFile: OBDTester.bin
  ILINK.IlinkOutputFile: OBDTester.out
  ILINK.IlinkIcfFile: ..\..\..\BSP\OBD\AT32F413xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release_V1_6 (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F403ACGT7 ArteryTek AT32F403ACGT7
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F403ACGT7; USE_BVLOADER; ZDEBUG; LIBRARY_VERSION; SYSTICK
  ICCARM.CCIncludePath2: ..\..\..\Zox\drivers\include; ..\..\..\Zox\utils; ..\..\..\Zox\include; ..\..\..\Zox; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\OBD-V1.6; ..\..\..\APP\; ..\..\..\APP\include; ..\..\..\lib\CMSIS\CM4\DeviceSupport; ..\..\..\lib\AT32F4xx_StdPeriph_Driver\src; ..\..\..\lib\AT32F4xx_StdPeriph_Driver\inc; ..\..\..\lib\CMSIS\CM4\DeviceSupport\startup\iar; ..\..\..\lib\CMSIS\CM4\CoreSupport; ..\..\..\Zox\FreeRTOS\include; ..\..\..\Zox\FreeRTOS\portable\IAR\ARM_CM4F
  ILINK.IlinkIcfFile: ..\..\..\BSP\OBD-V1.6\AT32F403AxG.icf
  group APP
    ../../Main/: OBDMain.cpp OBDTesterMain.cpp
  group BSP
    ../../../BSP/: at32f4xx_it.c system_at32f4xx.c
  group BSP/OBD
    ../../../BSP/OBD/: board.cpp
  group BSP/OBD-V1.6
    ../../../BSP/OBD-V1.6/: board.cpp
  group Lib/AT32F4xx_StdPeriph_Driver
    ../../../lib/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_crc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c misc.c
  group Lib/CMSIS
    ../../../lib/CMSIS/CM4/DeviceSupport/startup/iar/: startup_at32f413rx_md.s
  group Zox
    ../../../Zox/: main.cpp zdebug.cpp Zox.cpp
  group Zox/drivers
    ../../../Zox/drivers/: Driver.cpp DrvCAN.cpp DrvGPIO.cpp DrvGPTimer.cpp DrvTJA1041.cpp DrvUSART.cpp DrvWatchDog.cpp
  group Zox/FreeRTOS/core
    ../../../Zox/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Zox/FreeRTOS/port
    ../../../Zox/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../Zox/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Zox/utils
    ../../../Zox/utils/: Delay.cpp RingBuffer.cpp SysTick.c
