<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_NISSAN</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_Sprinter_OBD</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_Sprinter_PSM</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_Fiat_DUCATO</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_Iveco_DAILY2</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_Maxus_LDV2021</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_Fiat_talento_2017</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release-V1.2-Iveco-Daily3</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release-V1.2-Iveco-Radio2</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_IvecoS_Way2</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_Ford_Transit3</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_Citroen_E-Dispatch</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_DAF_CF</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_Landrover_Defender</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_VOLVO_FH</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release-v1.2-Iveco-Daily4</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release-v1.2-Iveco-Daily5</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_LEVC</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_Sprinter_OBD_2</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_DAF_1</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_Ford_Fiesta</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_Hyundai_Kona</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_v1.2_Ford_Etransit</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release_AppLib</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>APP</name>
    <group>
      <name>C06Controller</name>
      <file>
        <name>$PROJ_DIR$\..\..\Controller\C06Controller\C06Controller.cpp</name>
      </file>
    </group>
    <group>
      <name>CanDetector</name>
      <file>
        <name>$PROJ_DIR$\..\..\CanDetector\CanDetector.cpp</name>
      </file>
    </group>
    <group>
      <name>CanHub</name>
      <file>
        <name>$PROJ_DIR$\..\..\CanHub\CanHub.cpp</name>
      </file>
    </group>
    <group>
      <name>Car</name>
      <group>
        <name>Citroen_EDispatch</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Citroen_EDispatch\Citroen_EDispatch.cpp</name>
        </file>
      </group>
      <group>
        <name>DAF_1</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\DAF_1\DAF_1.cpp</name>
        </file>
      </group>
      <group>
        <name>DAF_CF</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\DAF_CF\DAF_CF.cpp</name>
        </file>
      </group>
      <group>
        <name>DAF_CF1</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\DAF_CF1\DAF_CF1.cpp</name>
        </file>
      </group>
      <group>
        <name>Fiat_Ducato</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Fiat_Ducato\Fiat_Ducato.cpp</name>
        </file>
      </group>
      <group>
        <name>Fiat_talento_2017</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Fiat_Talento_2017\Fiat_Talento_2017.cpp</name>
        </file>
      </group>
      <group>
        <name>Ford_Etransit</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Ford_Etransit\Ford_Etransit.cpp</name>
        </file>
      </group>
      <group>
        <name>Ford_Fiesta</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Ford_Fiesta\Ford_Fiesta.cpp</name>
        </file>
      </group>
      <group>
        <name>Ford_Transit</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Ford_Transit\Ford_Transit.cpp</name>
        </file>
      </group>
      <group>
        <name>Ford_Transit2</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Ford_Transit2\Ford_Transit2.cpp</name>
        </file>
      </group>
      <group>
        <name>Ford_Transit3</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Ford_Transit3\Ford_Transit3.cpp</name>
        </file>
      </group>
      <group>
        <name>Hyundai_Kona</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Hyundai_Kona\Hyundai_Kona.cpp</name>
        </file>
      </group>
      <group>
        <name>Iveco</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\IVECO\Iveco.cpp</name>
        </file>
      </group>
      <group>
        <name>IVECO_Daily</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\IVECO_Daily\IVECO_Daily.cpp</name>
        </file>
      </group>
      <group>
        <name>IVECO_Daily2</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\IVECO_Daily2\IVECO_Daily2.cpp</name>
        </file>
      </group>
      <group>
        <name>IVECO_Daily3</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\IVECO_Daily3\IVECO_Daily3.cpp</name>
        </file>
      </group>
      <group>
        <name>IVECO_Daily4</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\IVECO_Daily4\IVECO_Daily4.cpp</name>
        </file>
      </group>
      <group>
        <name>IVECO_Daily5</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\IVECO_Daily5\IVECO_Daily5.cpp</name>
        </file>
      </group>
      <group>
        <name>Iveco_Radio</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\IVECO-radio\Iveco_Radio.cpp</name>
        </file>
      </group>
      <group>
        <name>Iveco_Radio2</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\IVECO-radio2\Iveco_Radio2.cpp</name>
        </file>
      </group>
      <group>
        <name>Iveco_Yellow</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\IVECO-Yellow\Iveco_Yellow.cpp</name>
        </file>
      </group>
      <group>
        <name>IvecoS</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\IVECOS\IVECOS.cpp</name>
        </file>
      </group>
      <group>
        <name>IvecoS_Way</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\IVECOS-WAY\IvecoS_Way.cpp</name>
        </file>
      </group>
      <group>
        <name>IvecoS_Way2</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\IVECOS-WAY2\IvecoS_Way2.cpp</name>
        </file>
      </group>
      <group>
        <name>Landrover_Defender</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Landrover_Defender\Landrover_Defender.cpp</name>
        </file>
      </group>
      <group>
        <name>LDV_Maxus_2021</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\LDV_Maxus_2021\LDV_Maxus_2021.cpp</name>
        </file>
      </group>
      <group>
        <name>LDV_Maxus_2021_2</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\LDV_Maxus_2021_2\LDV_Maxus_2021_2.cpp</name>
        </file>
      </group>
      <group>
        <name>LDV_Maxus_2021_3</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\LDV_Maxus_2021_3\LDV_Maxus_2021_3.cpp</name>
        </file>
      </group>
      <group>
        <name>LDV_Maxus_2021_4</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\LDV_Maxus_2021_4\LDV_Maxus_2021_4.cpp</name>
        </file>
      </group>
      <group>
        <name>LDV_Maxus_2021_5</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\LDV_Maxus_2021_5\LDV_Maxus_2021_5.cpp</name>
        </file>
      </group>
      <group>
        <name>LDV_Maxus_2021_6</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\LDV_Maxus_2021_6\LDV_Maxus_2021_6.cpp</name>
        </file>
      </group>
      <group>
        <name>LEVC</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\LEVC\LEVC.cpp</name>
        </file>
      </group>
      <group>
        <name>MAN_TGS</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\MAN_TGS\MAN_TGS.cpp</name>
        </file>
      </group>
      <group>
        <name>MAN_TGS2</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\MAN_TGS2\MAN_TGS2.cpp</name>
        </file>
      </group>
      <group>
        <name>Maxus</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Maxus\Maxus.cpp</name>
        </file>
      </group>
      <group>
        <name>Nissan_E-NV200</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Nissan_E-NV200\Nissan.cpp</name>
        </file>
      </group>
      <group>
        <name>Sprinter_OBD</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Sprinter_OBD\Sprinter_OBD.cpp</name>
        </file>
      </group>
      <group>
        <name>Sprinter_OBD_2</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Sprinter_OBD_2\Sprinter_OBD_2.cpp</name>
        </file>
      </group>
      <group>
        <name>Sprinter_PSM</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Sprinter_Psm\Sprinter_Psm.cpp</name>
        </file>
      </group>
      <group>
        <name>VOLVO_FH</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\VOLVO_FH\VOLVO_FH.cpp</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\Car\Car.cpp</name>
      </file>
    </group>
    <group>
      <name>Forwarder</name>
      <file>
        <name>$PROJ_DIR$\..\..\Forwarder\Forwarder.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Forwarder\GearForwarder.cpp</name>
      </file>
    </group>
    <group>
      <name>Main</name>
      <file>
        <name>$PROJ_DIR$\..\..\Main\appMain.cpp</name>
      </file>
    </group>
    <group>
      <name>PV</name>
      <file>
        <name>$PROJ_DIR$\..\..\PV\C06_PV\C06_PV.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\PV\PV.cpp</name>
      </file>
    </group>
  </group>
  <group>
    <name>BSP</name>
    <group>
      <name>C06</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\BSP\at32f4xx_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\BSP\C06\board.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\BSP\system_at32f4xx.c</name>
      </file>
    </group>
  </group>
  <group>
    <name>Lib</name>
    <group>
      <name>AT32F4xx_StdPeriph_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_acc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_bkp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_wwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\misc.c</name>
      </file>
    </group>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\CMSIS\CM4\DeviceSupport\startup\iar\startup_at32f413rx_md.s</name>
      </file>
    </group>
  </group>
  <group>
    <name>Zox</name>
    <group>
      <name>drivers</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\Driver.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvCAN.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvGPIO.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvGPTimer.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvLED.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvPWR.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvSPI.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvTJA1041.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvUSART.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvWatchDog.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvWindowWatchDog.cpp</name>
      </file>
    </group>
    <group>
      <name>DrvFs</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvFs\diskio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvFs\DrvFs.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvFs\SPI_SD_driver.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvFs\tff.c</name>
      </file>
    </group>
    <group>
      <name>FreeRTOS</name>
      <group>
        <name>core</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\croutine.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\event_groups.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\list.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\queue.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\tasks.c</name>
          <configuration>
            <name>release</name>
          </configuration>
          <configuration>
            <name>release_NISSAN</name>
          </configuration>
          <configuration>
            <name>release_v1.2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Sprinter_OBD</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Sprinter_PSM</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Fiat_DUCATO</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Iveco_DAILY2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Maxus_LDV2021</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Fiat_talento_2017</name>
          </configuration>
          <configuration>
            <name>release-V1.2-Iveco-Daily3</name>
          </configuration>
          <configuration>
            <name>release-V1.2-Iveco-Radio2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_IvecoS_Way2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Ford_Transit3</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Citroen_E-Dispatch</name>
          </configuration>
          <configuration>
            <name>release_v1.2_DAF_CF</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Landrover_Defender</name>
          </configuration>
          <configuration>
            <name>release_v1.2_VOLVO_FH</name>
          </configuration>
          <configuration>
            <name>release-v1.2-Iveco-Daily4</name>
          </configuration>
          <configuration>
            <name>release-v1.2-Iveco-Daily5</name>
          </configuration>
          <configuration>
            <name>release_v1.2_LEVC</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Sprinter_OBD_2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_DAF_1</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Ford_Fiesta</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Hyundai_Kona</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Ford_Etransit</name>
          </configuration>
          <configuration>
            <name>release_AppLib</name>
          </configuration>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\timers.c</name>
        </file>
      </group>
      <group>
        <name>port</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\include\FreeRTOSConfig.h</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\portable\MemMang\heap_4.c</name>
          <configuration>
            <name>release</name>
          </configuration>
          <configuration>
            <name>release_NISSAN</name>
          </configuration>
          <configuration>
            <name>release_v1.2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Sprinter_OBD</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Sprinter_PSM</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Fiat_DUCATO</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Iveco_DAILY2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Maxus_LDV2021</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Fiat_talento_2017</name>
          </configuration>
          <configuration>
            <name>release-V1.2-Iveco-Daily3</name>
          </configuration>
          <configuration>
            <name>release-V1.2-Iveco-Radio2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_IvecoS_Way2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Ford_Transit3</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Citroen_E-Dispatch</name>
          </configuration>
          <configuration>
            <name>release_v1.2_DAF_CF</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Landrover_Defender</name>
          </configuration>
          <configuration>
            <name>release_v1.2_VOLVO_FH</name>
          </configuration>
          <configuration>
            <name>release-v1.2-Iveco-Daily4</name>
          </configuration>
          <configuration>
            <name>release-v1.2-Iveco-Daily5</name>
          </configuration>
          <configuration>
            <name>release_v1.2_LEVC</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Sprinter_OBD_2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_DAF_1</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Ford_Fiesta</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Hyundai_Kona</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Ford_Etransit</name>
          </configuration>
          <configuration>
            <name>release_AppLib</name>
          </configuration>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\portable\IAR\ARM_CM4F\port.c</name>
          <configuration>
            <name>release</name>
          </configuration>
          <configuration>
            <name>release_NISSAN</name>
          </configuration>
          <configuration>
            <name>release_v1.2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Sprinter_OBD</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Sprinter_PSM</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Fiat_DUCATO</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Iveco_DAILY2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Maxus_LDV2021</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Fiat_talento_2017</name>
          </configuration>
          <configuration>
            <name>release-V1.2-Iveco-Daily3</name>
          </configuration>
          <configuration>
            <name>release-V1.2-Iveco-Radio2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_IvecoS_Way2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Ford_Transit3</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Citroen_E-Dispatch</name>
          </configuration>
          <configuration>
            <name>release_v1.2_DAF_CF</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Landrover_Defender</name>
          </configuration>
          <configuration>
            <name>release_v1.2_VOLVO_FH</name>
          </configuration>
          <configuration>
            <name>release-v1.2-Iveco-Daily4</name>
          </configuration>
          <configuration>
            <name>release-v1.2-Iveco-Daily5</name>
          </configuration>
          <configuration>
            <name>release_v1.2_LEVC</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Sprinter_OBD_2</name>
          </configuration>
          <configuration>
            <name>release_v1.2_DAF_1</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Ford_Fiesta</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Hyundai_Kona</name>
          </configuration>
          <configuration>
            <name>release_v1.2_Ford_Etransit</name>
          </configuration>
          <configuration>
            <name>release_AppLib</name>
          </configuration>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\portable\IAR\ARM_CM4F\portasm.s</name>
        </file>
      </group>
    </group>
    <group>
      <name>utils</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\utils\Delay.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\utils\RingBuffer.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\utils\SysTick.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\Zox\main.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Zox\zdebug.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Zox\Zox.cpp</name>
    </file>
  </group>
</project>


