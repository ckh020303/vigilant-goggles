# IAR project C06.ewp, settings and files
configuration release (ARM)
  General.OGChipSelectEditMenu: AT32F413RB ArteryTek AT32F413RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\Zox\drivers\include; ..\..\..\Zox\utils; ..\..\..\Zox\include; ..\..\..\Zox; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\C06; ..\..\..\APP\; ..\..\..\APP\include; ..\..\..\lib\CMSIS\CM4\DeviceSupport; ..\..\..\lib\AT32F4xx_StdPeriph_Driver\src; ..\..\..\lib\AT32F4xx_StdPeriph_Driver\inc; ..\..\..\lib\CMSIS\CM4\DeviceSupport\startup\iar; ..\..\..\lib\CMSIS\CM4\CoreSupport; ..\..\..\Zox\FreeRTOS\include; ..\..\..\Zox\drivers\DrvFs; ..\..\..\Zox\FreeRTOS\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  AARM.AUserIncludes: E:\git\C02Lite_Atery\C02Lite_Atery\Zox\FreeRTOS\include
  OBJCOPY.OOCOutputFile: C06.bin
  ILINK.IlinkOutputFile: C06.out
  ILINK.IlinkIcfFile: ..\..\..\BSP\C06\AT32F413xB.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release_NISSAN (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; NISSAN
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_Sprinter_OBD (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; SPRINTER_OBD
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_Sprinter_PSM (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; SPRINTER_PSM
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_Fiat_DUCATO (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; FIAT_DUCATO
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_Iveco_DAILY2 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; IVECO_DAILY2
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_Maxus_LDV2021 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; LDV_MAXUS_2021
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_Fiat_talento_2017 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; FIAT_TALENTO_2017
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release-V1.2-Iveco-Daily3 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; IVECO_DAILY3
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release-V1.2-Iveco-Radio2 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; IVECO_RADIO2
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_IvecoS_Way2 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; IVECOS_WAY2
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_Ford_Transit3 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; FORD_TRANSIT3
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_Citroen_E-Dispatch (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; CITROEN_EDISPATCH
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_DAF_CF (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; DAF_CF
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_Landrover_Defender (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; Landrover_Defender
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_VOLVO_FH (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; VOLVO_FH
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release-v1.2-Iveco-Daily4 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; IVECO_DAILY4
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release-v1.2-Iveco-Daily5 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; IVECO_DAILY5; NEED_DELAY_SLEEP
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_LEVC (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; Levc; NEED_DELAY_SLEEP
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_Sprinter_OBD_2 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; SPRINTER_OBD_2
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_DAF_1 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; DAF_1
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_Ford_Fiesta (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; FORD_FIESTA
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_Hyundai_Kona (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; HYUNDAI_KONA
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_v1.2_Ford_Etransit (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C06; LIBRARY_VERSION; SYSTICK; C06_V1_2; FORD_ETRANSIT
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
configuration release_AppLib (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: as above
  OBJCOPY.OOCOutputFile: C06AT.bin
  ILINK.IlinkOutputFile: C06AT.out
  group APP/C06Controller
    ../../Controller/C06Controller/: C06Controller.cpp
  group APP/CanDetector
    ../../CanDetector/: CanDetector.cpp
  group APP/CanHub
    ../../CanHub/: CanHub.cpp
  group APP/Car
    ../../Car/: Car.cpp
  group APP/Car/Citroen_EDispatch
    ../../Car/Citroen_EDispatch/: Citroen_EDispatch.cpp
  group APP/Car/DAF_1
    ../../Car/DAF_1/: DAF_1.cpp
  group APP/Car/DAF_CF
    ../../Car/DAF_CF/: DAF_CF.cpp
  group APP/Car/DAF_CF1
    ../../Car/DAF_CF1/: DAF_CF1.cpp
  group APP/Car/Fiat_Ducato
    ../../Car/Fiat_Ducato/: Fiat_Ducato.cpp
  group APP/Car/Fiat_talento_2017
    ../../Car/Fiat_Talento_2017/: Fiat_Talento_2017.cpp
  group APP/Car/Ford_Etransit
    ../../Car/Ford_Etransit/: Ford_Etransit.cpp
  group APP/Car/Ford_Fiesta
    ../../Car/Ford_Fiesta/: Ford_Fiesta.cpp
  group APP/Car/Ford_Transit
    ../../Car/Ford_Transit/: Ford_Transit.cpp
  group APP/Car/Ford_Transit2
    ../../Car/Ford_Transit2/: Ford_Transit2.cpp
  group APP/Car/Ford_Transit3
    ../../Car/Ford_Transit3/: Ford_Transit3.cpp
  group APP/Car/Hyundai_Kona
    ../../Car/Hyundai_Kona/: Hyundai_Kona.cpp
  group APP/Car/Iveco
    ../../Car/IVECO/: Iveco.cpp
  group APP/Car/IVECO_Daily
    ../../Car/IVECO_Daily/: IVECO_Daily.cpp
  group APP/Car/IVECO_Daily2
    ../../Car/IVECO_Daily2/: IVECO_Daily2.cpp
  group APP/Car/IVECO_Daily3
    ../../Car/IVECO_Daily3/: IVECO_Daily3.cpp
  group APP/Car/IVECO_Daily4
    ../../Car/IVECO_Daily4/: IVECO_Daily4.cpp
  group APP/Car/IVECO_Daily5
    ../../Car/IVECO_Daily5/: IVECO_Daily5.cpp
  group APP/Car/Iveco_Radio
    ../../Car/IVECO-radio/: Iveco_Radio.cpp
  group APP/Car/Iveco_Radio2
    ../../Car/IVECO-radio2/: Iveco_Radio2.cpp
  group APP/Car/Iveco_Yellow
    ../../Car/IVECO-Yellow/: Iveco_Yellow.cpp
  group APP/Car/IvecoS
    ../../Car/IVECOS/: IVECOS.cpp
  group APP/Car/IvecoS_Way
    ../../Car/IVECOS-WAY/: IvecoS_Way.cpp
  group APP/Car/IvecoS_Way2
    ../../Car/IVECOS-WAY2/: IvecoS_Way2.cpp
  group APP/Car/Landrover_Defender
    ../../Car/Landrover_Defender/: Landrover_Defender.cpp
  group APP/Car/LDV_Maxus_2021
    ../../Car/LDV_Maxus_2021/: LDV_Maxus_2021.cpp
  group APP/Car/LDV_Maxus_2021_2
    ../../Car/LDV_Maxus_2021_2/: LDV_Maxus_2021_2.cpp
  group APP/Car/LDV_Maxus_2021_3
    ../../Car/LDV_Maxus_2021_3/: LDV_Maxus_2021_3.cpp
  group APP/Car/LDV_Maxus_2021_4
    ../../Car/LDV_Maxus_2021_4/: LDV_Maxus_2021_4.cpp
  group APP/Car/LDV_Maxus_2021_5
    ../../Car/LDV_Maxus_2021_5/: LDV_Maxus_2021_5.cpp
  group APP/Car/LDV_Maxus_2021_6
    ../../Car/LDV_Maxus_2021_6/: LDV_Maxus_2021_6.cpp
  group APP/Car/LEVC
    ../../Car/LEVC/: LEVC.cpp
  group APP/Car/MAN_TGS
    ../../Car/MAN_TGS/: MAN_TGS.cpp
  group APP/Car/MAN_TGS2
    ../../Car/MAN_TGS2/: MAN_TGS2.cpp
  group APP/Car/Maxus
    ../../Car/Maxus/: Maxus.cpp
  group APP/Car/Nissan_E-NV200
    ../../Car/Nissan_E-NV200/: Nissan.cpp
  group APP/Car/Sprinter_OBD
    ../../Car/Sprinter_OBD/: Sprinter_OBD.cpp
  group APP/Car/Sprinter_OBD_2
    ../../Car/Sprinter_OBD_2/: Sprinter_OBD_2.cpp
  group APP/Car/Sprinter_PSM
    ../../Car/Sprinter_Psm/: Sprinter_Psm.cpp
  group APP/Car/VOLVO_FH
    ../../Car/VOLVO_FH/: VOLVO_FH.cpp
  group APP/Forwarder
    ../../Forwarder/: Forwarder.cpp GearForwarder.cpp
  group APP/Main
    ../../Main/: appMain.cpp
  group APP/PV
    ../../PV/C06_PV/: C06_PV.cpp
    ../../PV/: PV.cpp
  group BSP/C06
    ../../../BSP/: at32f4xx_it.c system_at32f4xx.c
    ../../../BSP/C06/: board.cpp
  group Lib/AT32F4xx_StdPeriph_Driver
    ../../../lib/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_crc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c misc.c
  group Lib/CMSIS
    ../../../lib/CMSIS/CM4/DeviceSupport/startup/iar/: startup_at32f413rx_md.s
  group Zox
    ../../../Zox/: main.cpp zdebug.cpp Zox.cpp
  group Zox/drivers
    ../../../Zox/drivers/: Driver.cpp DrvCAN.cpp DrvGPIO.cpp DrvGPTimer.cpp DrvLED.cpp DrvPWR.cpp DrvSPI.cpp DrvTJA1041.cpp DrvUSART.cpp DrvWatchDog.cpp DrvWindowWatchDog.cpp
  group Zox/DrvFs
    ../../../Zox/drivers/DrvFs/: diskio.c DrvFs.cpp SPI_SD_driver.c tff.c
  group Zox/FreeRTOS/core
    ../../../Zox/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Zox/FreeRTOS/port
    ../../../Zox/FreeRTOS/include/: FreeRTOSConfig.h
    ../../../Zox/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../Zox/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Zox/utils
    ../../../Zox/utils/: Delay.cpp RingBuffer.cpp SysTick.c
