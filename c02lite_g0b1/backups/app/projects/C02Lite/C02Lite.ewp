# IAR project C02Lite.ewp, settings and files
configuration debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F105xC ST STM32F105xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; ZDEBUG; USE_DOUBLE_CAN; PRODUCT_VARIANT_D02S_VW
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\Zox\drivers\include; ..\..\..\Zox\utils\include; ..\..\..\Zox\include; ..\..\..\Zox; ..\..\..\Zox\irq; ..\..\..\Zox\irq\STM32F10xxx; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\RVC-D02VW; ..\..\..\APP\; ..\..\..\APP\include; ..\..\..\APP\RVC-D02\include; ..\..\..\lib\STM32F10x_StdPeriph_Driver\inc; ..\..\..\lib\CMSIS\CM3\CoreSupport; ..\..\..\lib\CMSIS\CM3\DeviceSupport\ST\STM32F10x; ..\..\..\lib\STM32_CPAL_Driver\inc; ..\..\..\lib\STM32_CPAL_Driver\devices\stm32f10x; ..\..\..\uCOS-II\Source; ..\..\..\uCOS-II\Ports\ARM-Cortex-M3\Generic\IAR\; ..\..\..\uCOS-II\Ports\ARM-Cortex-M3\stm32f10x\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: rvc02.bin
  ILINK.IlinkOutputFile: STM32F10x_PROJ.out
  ILINK.IlinkIcfFile: ..\..\..\BSP\RVC-D02VW-CQY\stm32f10x_flash_debug.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F413RB ArteryTek AT32F413RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C02; LIBRARY_VERSION; SYSTICK; C02
  ICCARM.CCIncludePath2: ..\..\..\Zox\drivers\include; ..\..\..\Zox\utils; ..\..\..\Zox\include; ..\..\..\Zox; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\C02; ..\..\..\APP\; ..\..\..\APP\include; ..\..\..\lib\CMSIS\CM4\DeviceSupport; ..\..\..\lib\AT32F4xx_StdPeriph_Driver\src; ..\..\..\lib\AT32F4xx_StdPeriph_Driver\inc; ..\..\..\lib\CMSIS\CM4\DeviceSupport\startup\iar; ..\..\..\lib\CMSIS\CM4\CoreSupport; ..\..\..\Zox\FreeRTOS\include; ..\..\..\Zox\drivers\DrvFs; ..\..\..\Zox\FreeRTOS\portable\IAR\ARM_CM4F
  AARM.AUserIncludes: E:\git\C02Lite_Atery\C02Lite_Atery\Zox\FreeRTOS\include
  OBJCOPY.OOCOutputFile: C02Lite.bin
  ILINK.IlinkIcfFile: ..\..\..\BSP\C02\AT32F413xB.icf
configuration Tester (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F413RB ArteryTek AT32F413RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C02_TESTER; LIBRARY_VERSION; SYSTICK
  ICCARM.CCIncludePath2: as above
  AARM.AUserIncludes: E:\git\C02Lite_Atery\C02Lite_Atery\Zox\FreeRTOS\include
  OBJCOPY.OOCOutputFile: C02Lite.bin
  ILINK.IlinkIcfFile: ..\..\..\BSP\C02\AT32F413xB.icf
configuration APPLIB (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F413RB ArteryTek AT32F413RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: as above
  ICCARM.CCIncludePath2: ..\..\..\Zox\drivers\include; ..\..\..\Zox\utils; ..\..\..\Zox\include; ..\..\..\Zox; ..\..\..\; ..\..\..\BSP; ..\..\..\BSP\C02; ..\..\..\APP\; ..\..\..\APP\include; ..\..\..\lib\CMSIS\CM4\DeviceSupport; ..\..\..\lib\AT32F4xx_StdPeriph_Driver\src; ..\..\..\lib\AT32F4xx_StdPeriph_Driver\inc; ..\..\..\lib\CMSIS\CM4\DeviceSupport\startup\iar; ..\..\..\lib\CMSIS\CM4\CoreSupport; ..\..\..\Zox\FreeRTOS\include; ..\..\..\Zox\FreeRTOS\portable\IAR\ARM_CM4F
  AARM.AUserIncludes: E:\git\C02Lite_Atery\C02Lite_Atery\Zox\FreeRTOS\include
  OBJCOPY.OOCOutputFile: C02Lite.bin
  ILINK.IlinkIcfFile: E:\git\C02Lite_Atery\C02Lite_Atery\BSP\C02\AT32F413xC.icf
configuration release_VW_Caddy (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: AT32F413RB ArteryTek AT32F413RB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; AT32F413Rx_MD; ZDEBUG; USE_BVLOADER; PRODUCT_VARIANT_C02; LIBRARY_VERSION; SYSTICK; C02; PV_C02_VW_CADDY
  ICCARM.CCIncludePath2: as above
  AARM.AUserIncludes: E:\git\C02Lite_Atery\C02Lite_Atery\Zox\FreeRTOS\include
  OBJCOPY.OOCOutputFile: C02AT.bin
  ILINK.IlinkIcfFile: ..\..\..\BSP\C02\AT32F413xB.icf
  group app/CabHub
    ../../CanHub/: CanHub.cpp
  group app/CanDetector
    ../../CanDetector/: CanDetector.cpp
  group app/Car
    ../../Car/: Car.cpp
  group app/Car/AudiA3
    ../../Car/AudiA3/: AudiA3.cpp
  group app/Car/AudiA7_2019
    ../../Car/AudiA7_2019/: AudiA7_2019.cpp
  group app/Car/AudiQ7_0FD
    ../../Car/AudiQ7_0FD/: AudiQ7_0FD.cpp
  group app/Car/BenZ
    ../../Car/BenZ/: BenZ.cpp
  group app/Car/Benz_NewE
    ../../Car/Benz_NewE/: Benz_NewE.cpp
  group app/Car/BenzC
    ../../Car/BenzC/: BenzC.cpp
  group app/Car/BenzS
    ../../Car/BenzS/: BenZS.cpp
  group app/Car/Golf7
    ../../Car/Golf7/: Golf7.cpp
  group app/Car/VWCaddy
    ../../Car/VWCaddy/: VWCaddy.cpp
  group app/Controller
    ../../Controller/C02Controller/: Controller.cpp
  group app/Forwarder
    ../../Forwarder/: ExForwarder.cpp Forwarder.cpp GearForwarder.cpp
  group app/Main
    ../../Main/: appMain.cpp
  group app/PV
    ../../PV/C02_PV/: C02_PV.cpp
    ../../PV/C02_TESTER_PV/: C02_TESTER_PV.cpp
    ../../PV/: PV.cpp
  group app/secure
    ../../secure/: Activatee.cpp Encryption.cpp receiveStr.cpp
  group BSP
    ../../../BSP/: at32f4xx_it.c system_at32f4xx.c
  group BSP/C02
    ../../../BSP/C02/: board.cpp
  group Lib/AT32F4xx_StdPeriph_Driver
    ../../../lib/AT32F4xx_StdPeriph_Driver/src/: at32f4xx_acc.c at32f4xx_adc.c at32f4xx_bkp.c at32f4xx_can.c at32f4xx_crc.c at32f4xx_dbgmcu.c at32f4xx_dma.c at32f4xx_exti.c at32f4xx_flash.c at32f4xx_gpio.c at32f4xx_i2c.c at32f4xx_iwdg.c at32f4xx_pwr.c at32f4xx_rcc.c at32f4xx_rtc.c at32f4xx_sdio.c at32f4xx_spi.c at32f4xx_tim.c at32f4xx_usart.c at32f4xx_wwdg.c misc.c
  group Lib/CMSIS
    ../../../lib/CMSIS/CM4/DeviceSupport/startup/iar/: startup_at32f413rx_md.s
  group Zox
    ../../../Zox/: main.cpp zdebug.cpp Zox.cpp
  group Zox/drivers
    ../../../Zox/drivers/: Driver.cpp DrvCAN.cpp DrvGPIO.cpp DrvGPTimer.cpp DrvTJA1041.cpp DrvUSART.cpp DrvWatchDog.cpp
  group Zox/FreeRTOS/core
    ../../../Zox/FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group Zox/FreeRTOS/port
    ../../../Zox/FreeRTOS/portable/MemMang/: heap_4.c
    ../../../Zox/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Zox/utils
    ../../../Zox/utils/: Delay.cpp RingBuffer.cpp SysTick.c
