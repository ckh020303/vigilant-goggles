<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Tester</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>APPLIB</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>app</name>
    <group>
      <name>CabHub</name>
      <file>
        <name>$PROJ_DIR$\..\..\CanHub\CanHub.cpp</name>
      </file>
    </group>
    <group>
      <name>CanDetector</name>
      <file>
        <name>$PROJ_DIR$\..\..\CanDetector\CanDetector.cpp</name>
      </file>
    </group>
    <group>
      <name>Car</name>
      <group>
        <name>AudiA3</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\AudiA3\AudiA3.cpp</name>
        </file>
      </group>
      <group>
        <name>AudiA7_2019</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\AudiA7_2019\AudiA7_2019.cpp</name>
        </file>
      </group>
      <group>
        <name>AudiQ7_0FD</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\AudiQ7_0FD\AudiQ7_0FD.cpp</name>
        </file>
      </group>
      <group>
        <name>BenZ</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\BenZ\BenZ.cpp</name>
        </file>
      </group>
      <group>
        <name>Benz_NewE</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Benz_NewE\Benz_NewE.cpp</name>
        </file>
      </group>
      <group>
        <name>BenzC</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\BenzC\BenzC.cpp</name>
        </file>
      </group>
      <group>
        <name>BenzS</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\BenzS\BenZS.cpp</name>
        </file>
      </group>
      <group>
        <name>Golf7</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\Golf7\Golf7.cpp</name>
        </file>
      </group>
      <group>
        <name>VWCaddy</name>
        <file>
          <name>$PROJ_DIR$\..\..\Car\VWCaddy\VWCaddy.cpp</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\..\..\Car\Car.cpp</name>
      </file>
    </group>
    <group>
      <name>Controller</name>
      <file>
        <name>$PROJ_DIR$\..\..\Controller\C02Controller\Controller.cpp</name>
      </file>
    </group>
    <group>
      <name>Forwarder</name>
      <file>
        <name>$PROJ_DIR$\..\..\Forwarder\ExForwarder.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Forwarder\Forwarder.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\Forwarder\GearForwarder.cpp</name>
      </file>
    </group>
    <group>
      <name>Main</name>
      <file>
        <name>$PROJ_DIR$\..\..\Main\appMain.cpp</name>
      </file>
    </group>
    <group>
      <name>PV</name>
      <file>
        <name>$PROJ_DIR$\..\..\PV\C02_PV\C02_PV.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\PV\C02_TESTER_PV\C02_TESTER_PV.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\PV\PV.cpp</name>
      </file>
    </group>
    <group>
      <name>secure</name>
      <file>
        <name>$PROJ_DIR$\..\..\secure\Activatee.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\secure\Encryption.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\secure\receiveStr.cpp</name>
      </file>
    </group>
  </group>
  <group>
    <name>BSP</name>
    <group>
      <name>C02</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\BSP\C02\board.cpp</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\BSP\at32f4xx_it.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\BSP\system_at32f4xx.c</name>
    </file>
  </group>
  <group>
    <name>Lib</name>
    <group>
      <name>AT32F4xx_StdPeriph_Driver</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_acc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_adc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_bkp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_can.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_crc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_dbgmcu.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_dma.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_exti.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_flash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_gpio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_i2c.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_iwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_pwr.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_rcc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_rtc.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_sdio.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_spi.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_tim.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_usart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\at32f4xx_wwdg.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\AT32F4xx_StdPeriph_Driver\src\misc.c</name>
      </file>
    </group>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\lib\CMSIS\CM4\DeviceSupport\startup\iar\startup_at32f413rx_md.s</name>
      </file>
    </group>
  </group>
  <group>
    <name>Zox</name>
    <group>
      <name>drivers</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\Driver.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvCAN.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvGPIO.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvGPTimer.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvTJA1041.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvUSART.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\drivers\DrvWatchDog.cpp</name>
      </file>
    </group>
    <group>
      <name>FreeRTOS</name>
      <group>
        <name>core</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\croutine.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\event_groups.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\list.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\queue.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\tasks.c</name>
          <configuration>
            <name>release</name>
          </configuration>
          <configuration>
            <name>Tester</name>
          </configuration>
          <configuration>
            <name>APPLIB</name>
          </configuration>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\timers.c</name>
        </file>
      </group>
      <group>
        <name>port</name>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\portable\MemMang\heap_4.c</name>
          <configuration>
            <name>release</name>
          </configuration>
          <configuration>
            <name>Tester</name>
          </configuration>
          <configuration>
            <name>APPLIB</name>
          </configuration>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\portable\IAR\ARM_CM4F\port.c</name>
          <configuration>
            <name>release</name>
          </configuration>
          <configuration>
            <name>Tester</name>
          </configuration>
          <configuration>
            <name>APPLIB</name>
          </configuration>
        </file>
        <file>
          <name>$PROJ_DIR$\..\..\..\Zox\FreeRTOS\portable\IAR\ARM_CM4F\portasm.s</name>
        </file>
      </group>
    </group>
    <group>
      <name>utils</name>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\utils\Delay.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\utils\RingBuffer.cpp</name>
      </file>
      <file>
        <name>$PROJ_DIR$\..\..\..\Zox\utils\SysTick.c</name>
      </file>
    </group>
    <file>
      <name>$PROJ_DIR$\..\..\..\Zox\main.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Zox\zdebug.cpp</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\..\Zox\Zox.cpp</name>
    </file>
  </group>
</project>


